# IAR project lib_lpc_board_nxp_lpcxpresso_1769.ewp, settings and files
configuration nxp_lpcxpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_17xx_40xx; ..\..\..\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\lpc_board\board_common; ..\..\..\lpc_board\boards_17xx_40xx\nxp_lpcxpresso_1769; $PROJ_DIR$; ..\..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_common
    ../../board_common/: lpc_phy_smsc87x0.c
  group board_nxp_lpcxpresso_1769
    ./: board.c board_sysinit.c
